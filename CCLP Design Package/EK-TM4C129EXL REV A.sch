# EAGLE board EK-TM4C129EXL REV A (EAGLE 6.5.0), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
PC5  (via drill 0.3) (continued)
  Bottom 0.152: X8.7 115.57,53.67 116.74,52.5 v116.74,49.23 | v99.06,47.93 99.06,39.01 97.54,37.49 v97.54,37.26 97.54,28.5 100.36,25.68 100.36,18.67 99.9,18.21 99.9,15.54 99.59,15.24 99.59,13.34 98.53,12.27 98.53,5.79 97.54,4.8 97.54,4.04 97.74,3.83 97.77,3.83 X11.21
PC6  (via drill 0.3)
  Top 0.152: v111.48,48.16 111.25,47.93 v101.35,47.93 | v100.81,37.03 100.43,36.65 94.79,36.65 94.34,37.11 85.5,37.11 84.66,36.27 77.8,36.27 76.96,37.11 70.64,37.11 67.06,40.69 57.61,40.69 57.53,40.77 53.11,40.77 52.88,40.54 52.88,39.67 U1.P$23
  Bottom 0.152: X8.9 112.01,53.59 112.01,48.69 v111.48,48.16 | v101.35,47.93 101.35,40.62 101.19,40.46 101.19,37.41 v100.81,37.03 100.81,34.82 100.58,34.52 100.58,27.43 103.1,24.92 103.1,14.33 101.35,12.57 101.35,4.95 100.33,3.94 X11.19
PC7  (via drill 0.3)
  Top 0.152: v101.8,37.49 101.8,36.96 101.19,36.35 94.56,36.35 94.11,36.8 85.72,36.8 84.89,35.97 77.57,35.97 76.73,36.8 70.41,36.8 66.83,40.39 57.45,40.39 57.38,40.46 53.34,40.46 53.19,40.31 53.19,39.41 U1.P$22
  Bottom 0.152: X11.17 102.87,7.09 101.8,8.15 101.8,12.5 103.4,14.1 103.4,25.22 100.97,27.66 100.97,32.38 101.8,33.22 v101.8,37.49 101.5,37.8 101.5,40.08 101.8,40.39 101.8,47.32 101.96,47.47 101.96,49.61 104.09,51.74 104.09,53.29 X8.15
PD0  (via drill 0.3)
  Top 0.152: X9.14 107.95,8.74 107.06,7.85 104.93,7.85 104.62,7.54 99.67,7.54 98.91,8.31 92.73,8.31 91.67,7.24 86.33,7.24 85.72,7.85 84.35,7.85 84.12,7.62 78.41,7.62 77.72,6.93 70.18,6.93 69.49,7.62 66.45,7.62 66.22,7.85 63.86,7.85 v63.25,7.24 | v62.18,32.23 61.87,32.54 58.65,32.54 U1.P$1
  Bottom 0.152: X11.50 63.25,2.36 v63.25,7.24 63.25,8.53 63.55,8.84 63.55,21.03 64.62,22.17 64.62,24.92 62.18,27.36 v62.18,32.23
PD1  (via drill 0.3)
  Top 0.152: X9.12 110.49,8 110.34,7.85 107.67,7.85 107.37,7.54 105.31,7.54 105,7.24 99.52,7.24 98.75,8 92.96,8 91.9,6.93 86.03,6.93 85.42,7.54 84.66,7.54 84.35,7.24 78.56,7.24 77.95,6.63 69.95,6.63 69.34,7.24 v65.84,7.24 | v65.99,33.53 63.78,33.53 63.09,32.84 59.74,32.84 58.9,33.68 58.77,33.68 U1.P$2
  Bottom 0.152: X11.48 64.8,1.29 64.85,1.29 65.84,2.29 v65.84,7.24 65.84,8.46 65.99,8.61 v65.99,33.53
PD2  (via drill 0.3)
  Top 0.152: v60.73,33.45 59.59,33.45 59.05,33.98 58.51,33.98 U1.P$3
  Bottom 0.152: X6.3 58.67,53.09 58.67,51.13 60.5,49.3 v60.73,33.45 60.73,32.46 61.87,31.39 61.87,27.13 64.31,24.69 64.31,22.33 63.25,21.18 61.87,19.81 61.87,4.95 61.19,4.27 61.19,2.77 X11.52
PD3  (via drill 0.3)
  Top 0.152: X8.13 107.95,54.46 106.68,53.19 93.04,53.19 v92.81,52.96 | v92.81,51.44 92.28,50.9 90.22,50.9 86.26,46.94 78.56,46.94 76.5,49 72.39,49 71.7,48.31 68.35,48.31 66.83,46.79 57.76,46.79 57.45,46.48 v56.31,46.48 | 56.16,32.99 v56.27,32.99 56.92,32.99 57.15,33.22 57.18,33.22 U1.P$4 | v57.99,19.89 59.21,19.89 59.66,20.19 v66.75,20.19
  Bottom 0.152: v92.81,52.96 v92.81,51.44 | v66.75,20.19 66.75,13.41 66.52,13.18 66.52,4.65 66.22,4.34 66.22,2.36 X11.46 | v57.99,19.89 57.99,20.5 57.91,20.57 57.91,26.75 56.92,27.74 56.92,31.17 56.24,31.85 56.24,32.92 v56.27,32.99 56.31,33.1 v56.31,46.48
PD4  (via drill 0.3)
  Top 0.152: v73.15,29.18 70.71,29.18 70.03,28.5 60.88,28.5 60.27,29.11 58.22,29.11 U1.P$125
  Bottom 0.152: X11.40 73.84,2.36 73.84,25.58 JP4.3 73.15,28.45 v73.15,29.18
PD5  (via drill 0.3)
  Top 0.152: v74.37,29.18 74.37,29.26 73.84,29.79 70.71,29.79 69.72,28.8 61.11,28.8 60.5,29.41 58.52,29.41 58.37,29.57 58.33,29.57 U1.P$126
  Bottom 0.152: X11.38 76.43,2.31 76.43,5.64 75.59,6.48 75.59,20.19 76.2,20.8 76.2,27.36 v74.37,29.18 73.84,29.72 73.84,33.22 74.91,34.29 JP5.3
PD6  (via drill 0.3)
  Top 0.152: U4.4 77.57,41.45 v77.57,40.54 | v76.96,29.72 74.98,29.72 74.6,30.1 70.03,30.1 v69.34,29.41 69.34,29.49 68.89,29.49 68.5,29.11 61.34,29.11 60.73,29.72 58.75,29.72 58.6,29.87 58.59,29.87 U1.P$127
  Bottom 0.152: v77.57,40.54 77.57,39.85 77.5,39.78 77.5,31.24 76.96,30.71 v76.96,29.72 | v69.34,29.41 69.34,28.35 68.28,27.28 68.28,15.01 68.12,14.86 68.12,13.03 68.43,12.72 68.43,11.73 68.12,11.43 68.12,9.22 68.35,8.99 68.35,8.08 68.12,7.85 68.12,4.5 68.81,3.81 68.81,2.31 X11.44
PD7  (via drill 0.3)
  Top 0.152: X8.14 107.09,52.07 105.54,50.52 102.79,50.52 102.03,49.76 90.91,49.76 87.17,46.02 77.8,46.02 76.43,47.4 68.89,47.4 66.37,44.88 v59.36,44.88 | v60.5,30.86 58.67,30.86 U1.P$128 | X11.42 71.42,1.27 69.95,2.74 58.67,2.74 v58.45,2.97
  Bottom 0.152: v59.36,44.88 59.36,43.81 59.13,43.59 59.13,35.97 59.28,35.81 59.28,32 60.43,30.86 v60.5,30.86 59.82,30.18 59.82,25.38 60.58,24.61 60.58,22.55 61.19,21.95 61.19,7.16 58.45,4.42 v58.45,2.97
PE0  (via drill 0.3)
  Top 0.152: X11.14 109.04,1.27 109.35,1.6 109.96,2.29 117.04,2.29 v117.12,2.21 | v66.06,37.34 65.23,38.18 59.97,38.18 59.21,37.41 55.17,37.41 54.71,36.96 54.69,36.96 U1.P$15 | X8.6 116.18,50.14 110.95,50.14 109.65,48.84 102.49,48.84 102.18,49.15 91.44,49.15 87.71,45.41 77.42,45.41 76.05,46.79 70.1,46.79 68.73,45.41 v68.2,45.41
  Bottom 0.152: X8.6 118.11,51.05 117.27,50.22 117.27,49.61 117.35,49.53 117.35,46.41 116.81,45.87 116.81,44.5 117.04,44.27 117.04,38.25 115.9,37.11 115.9,33.22 118.42,30.71 118.42,25.6 117.65,24.84 117.65,12.57 117.12,12.04 v117.12,2.21 | v66.06,37.34 66.45,37.34 67.28,38.18 67.28,44.5 v68.2,45.41
PE1  (via drill 0.3)
  Top 0.152: X11.16 106.45,1.27 106.91,1.75 107.44,2.29 109.5,2.29 109.8,2.59 116.2,2.59 v116.51,2.9 | v66.67,36.2 66.29,36.2 64.62,37.87 60.12,37.87 59.36,37.11 55.41,37.11 U1.P$14 | X8.8 114.17,50.67 106.83,50.67 105.31,49.15 102.87,49.15 102.56,49.45 91.14,49.45 87.4,45.72 77.65,45.72 76.28,47.09 69.88,47.09 69.49,46.71 v69.04,46.71
  Bottom 0.152: X8.8 116.05,51.59 116.05,48.23 116.43,47.85 116.51,47.78 116.51,44.35 116.74,44.12 116.74,38.48 115.21,36.96 115.21,33.3 118.11,30.4 118.11,25.83 117.35,25.07 117.35,12.8 116.66,12.12 116.66,3.05 v116.51,2.9 | v66.67,36.2 67.67,37.19 67.67,43.43 69.04,44.81 v69.04,46.71
PE2  (via drill 0.3)
  Top 0.152: v103.94,37.72 103.25,37.03 102.49,37.03 101.42,35.97 89.92,35.97 88.7,34.75 76.5,34.75 75.67,35.59 66.29,35.59 64.31,37.57 60.35,37.57 59.59,36.8 55.7,36.8 55.32,36.42 55.24,36.42 55.03,36.2 U1.P$13 | X8.10 112.88,52.07 111.78,50.98 106.53,50.98 105.69,50.14 103.4,50.14 v103.1,49.84
  Bottom 0.152: v103.1,49.84 102.26,49 102.26,42.06 104.24,40.08 104.24,38.02 v103.94,37.72 103.94,2.44 102.87,1.37 X11.18
PE3  (via drill 0.3)
  Top 0.152: v109.8,19.51 109.65,19.36 104.78,19.36 103.56,18.14 v102.18,18.14 | U1.P$12 55.93,36.5 59.74,36.5 60.5,37.26 64.08,37.26 66.06,35.28 75.44,35.28 76.28,34.44 88.92,34.44 90.14,35.66 101.65,35.66 102.64,36.65 103.94,36.65 104.7,37.41 104.7,39.93 106.6,41.83 v108.43,41.83
  Bottom 0.152: X8.12 110.49,50.44 108.36,48.31 108.36,42.75 108.43,42.67 v108.43,41.83 108.43,39.4 108.66,39.17 108.66,38.18 110.8,36.04 110.8,26.36 108.97,24.54 108.97,22.78 109.8,21.95 v109.8,19.51 | v102.18,18.14 101.42,17.37 101.42,14.1 99.21,11.89 99.21,2.39 X11.20
PE4  (via drill 0.3)
  Top 0.152: v100.81,17.53 115.21,17.53 116.59,16.15 v119.33,16.15 | 79.4,27.43 v79.32,27.43 76.43,27.43 75.59,28.27 70.94,28.27 70.56,27.89 60.5,27.89 59.89,28.5 57.7,28.5 U1.P$123 | v101.35,24.61 100.13,25.83 98.98,25.83 98.68,26.14 92.51,26.14 89.46,23.09 v79.4,23.09
  Bottom 0.152: X8.3 120.52,54.61 119.56,53.65 119.56,51.44 118.57,50.44 118.57,45.95 118.34,45.72 118.34,38.79 120.17,36.96 120.17,31.62 118.72,30.18 118.72,16.76 v119.33,16.15 | X11.22 98.83,2.31 98.83,12.04 100.81,14.02 v100.81,17.53 101.35,18.06 101.35,18.21 102.49,19.36 102.49,23.47 v101.35,24.61 | v79.4,23.09 79.4,27.36 v79.32,27.43
PE5  (via drill 0.3)
  Top 0.152: v108.05,29.34 108.05,28.88 105.99,26.82 101.8,26.82 100.66,27.96 99.14,27.96 98.6,27.43 v97.08,27.43 91.21,27.43 90.68,27.96 79.7,27.96 79.63,28.04 79.02,28.04 78.94,27.96 76.43,27.96 75.82,28.57 70.64,28.57 70.26,28.19 60.66,28.19 60.05,28.8 57.99,28.8 57.76,29.03 57.73,29.03 U1.P$124
  Bottom 0.152: X8.11 109.5,53.62 109.5,50.06 108.05,48.62 108.05,42.6 107.52,42.06 107.52,41.6 108.05,41.07 108.05,38.79 108.36,38.48 108.36,35.74 109.65,34.44 109.65,30.86 108.13,29.34 v108.05,29.34 | v97.08,27.43 97.08,26.9 99.75,24.23 99.75,18.97 99.29,18.52 99.29,18.36 97.23,16.31 97.23,4.72 96.77,4.19 96.77,1.83 96.24,1.29 95.63,1.29 95.56,1.22 X11.24
PF0  (via drill 0.3)
  Top 0.152: D4.A 32.91,6.24 v33.3,6.63 33.38,6.71 39.4,6.71 v40.39,5.71 | v39.09,13.79 34.82,13.79 34.67,13.79 v33.3,13.79 | v41.38,41.91 41.99,41.3 41.99,41 42.22,40.77 43.05,39.85 44.09,39.85 U1.P$42
  Bottom 0.152: v39.09,13.79 39.09,14.63 38.86,14.86 38.86,18.9 40.01,20.12 40.92,21.03 40.92,22.86 40.01,23.77 40.01,33.68 41.07,34.75 41.07,36.73 40.54,37.26 40.54,40.23 41.38,41.07 v41.38,41.91 | v33.3,13.79 33.3,10.29 33.38,10.21 33.38,7.32 33.3,7.24 v33.3,6.63 | X11.66 41.91,1.91 40.62,3.2 40.62,5.49 v40.39,5.71
PF1  (via drill 0.3)
  Top 0.152: X9.1 123.19,13.44 121.08,15.54 116.51,15.54 114.83,17.22 101.88,17.22 101.58,16.92 98.6,16.92 97.99,16.31 93.12,16.31 92.89,16.08 v92.05,16.08 | v90.53,31.55 89.92,31.55 89.53,31.17 81.46,31.17 81,30.71 69.04,30.71 68.12,29.79 63.48,29.79 61.49,31.77 56.69,31.77 56.39,32.08 54.86,32.08 54.33,32.61 52.43,32.61 52.12,32.92 46.79,32.92 v46.25,32.38 | v46.18,38.18 45.72,38.18 45.57,38.02 45.34,38.02 45.26,38.1 45.26,38.11 U1.P$43 | v47.85,18.97 47.55,18.67 44.04,18.67 43.28,17.91 38.86,17.91 v38.25,17.3
  Bottom 0.152: v92.05,16.08 90.37,17.75 90.37,24.46 91.29,25.38 91.29,26.67 91.06,26.9 91.06,30.18 90.53,30.71 v90.53,31.55 | v46.18,38.18 46.18,37.64 45.95,37.41 45.95,36.73 46.63,36.04 46.63,32.77 v46.25,32.38 46.79,31.85 46.79,31.39 46.33,30.94 46.33,26.06 47.4,24.99 47.4,22.4 48.16,21.64 48.16,19.81 47.85,19.51 v47.85,18.97 | v38.25,17.3 38.25,12.88 38.33,12.8 38.33,6.86 38.1,6.63 38.1,5.03 38.33,4.8 38.33,3.35 38.63,3.05 38.63,1.98 39.34,1.27 X11.68
PF2  (via drill 0.3)
  Top 0.152: 120.62,11.4 120.62,12.27 119.41,13.49 117.88,13.49 114.45,16.92 102.11,16.92 101.5,16.31 v98.98,16.31 | v96.77,30.79 88.09,30.79 88.01,30.86 81.69,30.86 81.23,30.4 69.27,30.4 68.35,29.49 63.25,29.49 61.27,31.47 56.54,31.47 56.24,31.77 54.56,31.77 54.03,32.31 52.2,32.31 51.89,32.61 47.7,32.61 v47.4,32.31 | v46.56,37.11 46.1,37.57 45.24,37.57 U1.P$44 | v44.58,6.33 43.28,6.33 43.2,6.4 40.31,6.4 39.4,7.32 v37.72,7.32 | 120.62,11.35 120.62,11.4 | 120.62,11.4 X9.3
  Bottom 0.152: v98.98,16.31 98.98,17.37 99.59,17.98 99.59,18.36 100.05,18.82 100.05,25.45 96.93,28.57 96.93,30.63 v96.77,30.79 | v46.56,37.11 46.94,36.73 46.94,32.77 v47.4,32.31 47.4,31.47 46.63,30.71 46.63,26.21 47.7,25.15 47.7,22.63 48.46,21.87 48.46,16.69 46.02,14.25 46.02,11.96 45.87,11.81 45.87,10.97 46.33,10.52 46.33,9.68 45.87,9.22 45.87,7.62 v44.58,6.33 | v37.72,7.32 37.72,4.65 38.02,4.34 38.02,1.68 37.8,1.45 37.34,1.45 37.29,1.4 37.11,1.4 X11.70
PF3  (via drill 0.3)
  Top 0.152: X9.5 113.84,15.7 v93.88,15.7 | v90.22,45.87 89.76,45.34 89.23,45.34 88.39,44.5 76.81,44.5 75.44,45.87 70.79,45.87 68.89,43.97 62.94,43.97 62.33,43.36 56.54,43.36 56.01,43.89 49.91,43.89 49.38,43.36 47.62,43.36 v47.09,42.82 | v45.19,36.96 45.19,37.03 44.1,38.12 U1.P$45 | v34.75,32.23 36.42,32.23 37.11,31.55 39.47,31.55 39.55,31.47 44.42,31.47 44.73,31.77 45.34,31.77 45.41,31.85 v45.49,31.85
  Bottom 0.152: v90.22,45.87 90.22,39.09 92.2,37.11 92.2,31.39 91.36,30.56 91.36,27.81 91.59,27.58 91.59,25.22 90.68,24.31 90.68,18.9 v93.88,15.7 | v47.09,42.82 46.71,42.44 46.71,40.69 45.19,39.17 v45.19,36.96 46.25,35.89 46.25,33.3 45.49,32.54 v45.49,31.85 45.41,31.85 | X11.72 34.29,2.29 35.28,3.28 35.28,4.57 34.06,5.79 34.06,19.43 34.52,19.89 34.52,31.55 34.75,31.77 v34.75,32.23
PF4  (via drill 0.3)
  Top 0.152: X11.64 44.45,1.4 44.27,1.37 44.2,1.45 43.28,1.45 42.44,2.29 38.79,2.29 38.56,2.06 37.64,2.06 37.41,2.29 33.38,2.29 33.22,2.13 32.54,2.13 32.38,2.29 28.35,2.29 v27.96,1.91 | v27.96,6.1 29.07,6.1 D3.A | v45.03,36.04 45.03,36.2 44.58,36.65 44.58,37.11 U1.P$46 | v44.73,32.38 44.2,32.38 44.04,32.23 43.36,32.23 42.9,31.77 39.78,31.77 39.7,31.85 37.41,31.85 36.35,32.92 34.59,32.92 34.14,32.46 34.14,32.31 33.76,31.93 31.85,31.93 v30.86,32.92
  Bottom 0.152: v27.96,1.91 v27.96,6.1 27.96,6.63 27.81,6.78 27.81,12.65 27.05,13.41 27.05,26.36 28.04,27.36 29.57,28.88 29.57,29.79 30.86,31.09 v30.86,32.92 | v45.03,36.04 45.87,35.2 45.87,33.45 44.81,32.38 v44.73,32.38
PG0  (via drill 0.3)
  Top 0.152: 115.59,11.43 111.63,15.39 98.15,15.39 97.84,15.09 93.34,15.09 92.96,15.47 90.3,15.47 87.86,17.91 86.64,17.91 v86.33,18.21 86.18,18.21 85.88,17.91 80.54,17.91 79.78,18.67 79.02,18.67 77.95,17.6 76.5,17.6 76.2,17.91 73.69,17.91 73.3,18.29 70.18,18.29 69.88,18.59 69.04,18.59 68.81,18.36 52.5,18.36 51.89,18.97 49.23,18.97 48.31,19.89 46.86,19.89 v46.63,19.58 | 43.81,36.16 v44.12,36.04 | v44.12,36.04 43.97,36.04 44.08,36.09 v44.12,36.04 | U1.P$49 43.94,36.04 v44.12,36.04
  Top 0.254: 115.59,11.43 X9.7
  Bottom 0.152: v86.33,18.21 86.33,17.53 86.11,17.3 86.11,13.49 85.42,12.8 85.42,7.47 85.65,7.24 85.65,6.55 85.11,6.02 85.11,3.83 X11.31 | v46.63,19.58 46.63,22.55 45.72,23.47 45.72,25.76 45.64,25.83 45.64,28.04 45.11,28.57 45.11,31.17 44.12,32.16 44.12,32.69 44.58,33.15 45.03,33.15 45.41,33.53 45.41,35.2 45.26,35.36 44.81,35.36 v44.12,36.04
PG1  (via drill 0.3)
  Top 0.152: v87.63,12.04 87.55,11.96 62.87,11.96 62.71,12.12 60.38,12.12 X7.1 | v57,32.38 55.09,32.38 53.65,33.83 51.82,33.83 50.29,35.43 43.66,35.43 43.28,35.81 43.28,36.12 42.69,36.71 U1.P$50 | v59.82,16.54 59.51,16.84 58.06,16.84 v57.76,16.54
  Bottom 0.152: X11.29 v87.63,12.04 | v57,32.38 57,31.62 57.23,31.39 57.23,27.89 58.22,26.9 58.22,20.95 58.6,20.57 58.6,18.36 57.76,17.53 57.76,16.56 57.73,16.56 v57.76,16.54 | X7.1 60.27,12.01 60.27,16.08 v59.82,16.54
PH0  (via drill 0.3)
  Top 0.152: v113.16,7.01 112.78,6.63 108.66,6.63 108.36,6.33 106.3,6.33 105.99,6.02 98.91,6.02 98.15,6.78 94.03,6.78 92.96,5.71 82.07,5.71 81.15,6.63 78.87,6.63 78.26,6.02 63.02,6.02 62.1,6.93 54.1,6.93 53.57,6.4 49.23,6.4 48.39,7.24 46.02,7.24 45.72,7.54 43.66,7.54 43.59,7.62 v43.13,7.62 | 50.44,40.69 50.44,40.62 | v49.15,38.33 49.15,39.55 49.53,39.93 49.76,39.93 50.44,40.61 50.44,40.62 | v48.84,34.82 48.54,35.13 45.72,35.13 45.34,34.75 v44.81,34.75 | U1.P$29 50.44,40.62
  Bottom 0.152: 112.93,3.81 X11.9 | 113.08,3.81 113.16,3.89 v113.16,7.01 | v43.13,7.62 43.43,7.92 43.43,10.41 X7.13 44.42,11.58 44.42,11.43 43.66,12.19 43.66,15.09 45.03,16.46 45.03,22.02 44.42,22.63 44.42,24.84 43.66,25.6 43.66,27.81 44.5,28.65 44.5,30.86 43.51,31.85 43.51,32.99 44.2,33.68 44.2,34.21 44.73,34.75 v44.81,34.75 | v49.15,38.33 49.15,37.87 48.46,37.19 48.46,35.2 v48.84,34.82 48.92,34.82
  Bottom 0.254: 113.08,3.81 X11.9
PH1  (via drill 0.3)
  Top 0.152: v112.24,7.24 111.94,6.93 108.43,6.93 108.13,6.63 106.07,6.63 105.77,6.33 99.06,6.33 98.3,7.09 93.8,7.09 92.73,6.02 82.3,6.02 81.38,6.93 78.72,6.93 78.11,6.33 63.25,6.33 62.33,7.24 53.87,7.24 53.34,6.71 49.38,6.71 48.54,7.54 46.25,7.54 45.95,7.85 43.97,7.85 43.51,8.31 42.9,8.31 42.37,7.77 v40.92,7.77 | v42.44,45.57 43.13,44.88 45.11,44.88 45.41,45.19 46.48,45.19 46.79,44.88 v48.31,44.88 | v48.92,40.39 49.63,40.39 U1.P$30
  Bottom 0.152: X11.11 110.57,3.81 110.49,4.42 X11.11 | X11.11 111.48,4.8 111.48,6.48 v112.24,7.24 | v40.92,7.77 40.92,10.44 X7.15 42.67,12.19 42.98,12.19 42.98,15.47 43.89,16.38 43.89,19.96 43.81,20.04 43.81,20.65 44.12,20.95 44.12,24.54 43.36,25.3 43.36,27.96 44.2,28.8 44.2,30.71 43.2,31.7 43.2,33.15 43.89,33.83 43.89,35.36 43.43,35.81 43.43,36.58 44.58,37.72 44.58,38.79 42.6,40.77 42.6,42.44 43.2,43.05 43.2,44.2 42.44,45.03 v42.44,45.57 | v48.31,44.88 48.31,44.35 48.84,43.81 48.84,40.39 v48.92,40.39
PH2  (via drill 0.3)
  Top 0.152: v118.64,6.4 118.64,5.11 118.34,4.8 115.14,4.8 114.61,4.27 114.07,4.27 113.54,4.8 109.96,4.8 109.04,3.89 108.03,3.89 X11.13 | v102.41,16.31 114.38,16.31 117.81,12.88 v119.02,12.88 | v98.98,37.57 98.37,38.18 94.94,38.18 94.79,38.02 84.81,38.02 83.97,37.19 78.56,37.19 77.72,38.02 71.32,38.02 67.74,41.6 58.14,41.6 57.61,42.14 55.24,42.14 54.71,42.67 50.67,42.67 50.52,42.52 50.52,41.83 U1.P$31
  Bottom 0.152: v118.64,6.4 118.64,8.36 X9.6 119.18,9.96 119.18,12.12 119.02,12.27 v119.02,12.88 | 98.98,37.49 v98.98,37.57 98.98,36.73 98.68,36.42 98.68,33.76 100.28,32.16 100.28,27.13 102.79,24.61 102.79,17.75 102.41,17.37 v102.41,16.31
PH3  (via drill 0.3)
  Top 0.152: 105.41,3.83 X11.15 106.45,3.81 107.44,4.8 109.5,4.8 109.8,5.11 114.15,5.11 v114.38,4.88 | U1.P$32 49.45,41.73 49.45,41.99 50.44,42.98 55.02,42.98 55.55,42.44 57.91,42.44 58.45,41.91 67.97,41.91 71.55,38.33 77.95,38.33 78.79,37.49 83.74,37.49 84.58,38.33 94.49,38.33 94.64,38.48 98.22,38.48 102.18,42.44 v110.03,42.44
  Bottom 0.152: X9.8 114.99,8.31 114.99,6.63 114.38,6.02 v114.38,4.88 | 115.59,8.91 X9.8 | X11.15 105.39,3.81 105.31,3.89 | X9.8 114.53,9.93 114.53,35.81 110.03,40.31 v110.03,42.44
PJ0  (via drill 0.3)
  Top 0.152: USR_SW1.P$2 6.33,7.62 6.55,7.39 v7.62,7.39 8.91,6.1 15.32,6.1 v19.36,10.13 19.81,10.13 20.88,11.2 23.39,11.2 27.96,15.77 41.07,15.77 41.68,16.38 44.42,16.38 45.19,17.14 50.67,17.14 51.36,16.46 54.41,16.46 v54.71,16.15 | v52.65,30.4 52.73,29.26 53.72,28.27 53.95,28.27 55.01,27.21 U1.P$116 | USR_SW1.P$1 6.38,15.32 6.71,15.32 6.71,15.47 v8.38,15.47
  Bottom 0.152: X11.82 20.57,2.29 20.57,5.56 19.36,6.78 v19.36,10.13 | v52.65,30.4 52.73,30.33 52.73,29.72 54.06,28.38 54.06,24.73 54.03,24.69 54.03,23.32 55.02,22.33 55.02,16.99 54.71,16.69 v54.71,16.15 | v8.38,15.47 8.38,14.25 7.62,13.49 v7.62,7.39
PJ1  (via drill 0.3)  (1 unrouted)
  Top 0.152: v55.93,16.46 55.55,16.76 51.51,16.76 50.83,17.45 44.96,17.45 44.2,16.69 41.45,16.69 40.84,16.08 27.74,16.08 23.16,11.51 19.2,11.51 18.52,10.82 v14.25,10.82 14.25,8.59 USR_SW2.P$2 | v14.25,12.65 14.25,13.95 14.55,14.51 USR_SW2.P$1 | v54.03,30.25 54.03,29.79 54.1,29.72 54.1,28.7 U1.P$117
  Bottom 0.152: X11.84 17.98,2.34 v17.98,10.82 | v14.25,10.82 v14.25,12.65 | v55.93,16.46 56.24,16.76 56.24,18.75 55.63,19.36 55.63,22.63 57,24 57,25.53 55.55,26.9 55.55,29.03 55.47,29.11 54.63,29.11 54.25,29.49 54.25,30.18 54.18,30.25 v54.03,30.25
PK0  (via drill 0.3)
  Top 0.152: v68.28,36.27 68.28,36.35 68.12,36.5 68.12,36.58 65.53,39.17 56.84,39.17 56.77,39.24 54.56,39.24 54.41,39.09 54.41,38.37 U1.P$18 53.58,37.57 52.27,36.27 v52.27,35.97 | v70.79,10.52 v92.05,10.52
  Bottom 0.152: X11.26 91.67,2.31 91.67,10.13 v92.05,10.52 | v52.27,35.97 52.27,36.42 53.19,37.34 53.19,42.9 52.58,43.51 52.5,49.99 50.49,51.99 49.61,51.99 X6.10 | 68.58,35.97 v68.28,36.27 69.27,35.28 69.27,32.92 70.03,32.16 70.03,28.57 68.58,27.13 68.58,23.24 69.72,23.24 70.26,22.71 70.26,21.57 71.17,20.65 71.17,11.43 70.79,11.05 v70.79,10.52
PK1  (via drill 0.3)
  Top 0.152: v88.92,36.12 87.86,35.05 76.81,35.05 75.97,35.89 69.88,35.89 66.29,39.47 57,39.47 56.92,39.55 54.18,39.55 54.1,39.47 54.1,38.63 U1.P$19 52.12,36.65 | 52.12,36.65 | 52.12,36.65 51.97,36.5 51.74,36.5 v51.28,36.04 51.13,35.89
  Bottom 0.152: X11.28 91.29,2.39 91.29,14.55 89.76,16.08 89.76,33.15 88.92,33.98 v88.92,36.12 | X6.12 48.01,51.05 50.9,51.05 52.2,49.76 52.2,43.43 52.88,42.75 52.88,37.64 v51.28,36.04
PK2  (via drill 0.3)
  Top 0.152: v87.71,36.12 87.02,36.12 86.26,35.36 77.04,35.36 76.2,36.2 70.03,36.2 66.45,39.78 57.15,39.78 57.07,39.85 53.95,39.85 53.8,39.7 53.8,38.89 U1.P$20 51.86,36.96 v51.28,36.96
  Bottom 0.152: 87.71,36.27 v87.71,36.12 87.71,34.59 89.46,32.84 89.46,15.85 90.53,14.78 90.53,11.43 89.15,10.06 89.15,2.79 X11.30 | v51.28,36.96 52.58,38.25 52.58,42.6 51.89,43.28 51.89,49.61 50.75,50.75 45.77,50.75 X6.14
PK3  (via drill 0.3)
  Top 0.152: 86.11,36.12 v86.03,36.12 85.57,36.12 85.11,35.66 77.34,35.66 76.5,36.5 70.18,36.5 66.6,40.08 57.3,40.08 57.23,40.16 53.65,40.16 53.49,40.01 53.49,39.15 U1.P$21 51.98,37.64 51.74,37.64 51.66,37.64 v51.36,37.95 | v50.29,50.14 49.68,50.75 43.2,50.75 41.91,52.05 X6.16
  Bottom 0.152: v86.03,36.12 86.03,35.66 89.15,32.54 89.15,20.04 89,19.89 89,15.85 90.14,14.71 90.14,11.58 88.85,10.29 88.85,3.35 87.78,2.29 86.11,2.29 X11.32 | v50.29,50.14 51.59,48.84 51.59,43.13 52.27,42.44 52.27,39.32 51.36,38.41 51.36,38.1 51.51,37.95 | 51.51,37.95 51.59,37.95 | 51.51,37.95 v51.36,37.95
PK4  (via drill 0.3)
  Top 0.152: v26.67,34.06 26.67,34.52 28.12,35.97 30.4,35.97 31.93,34.44 32.23,34.44 32.77,33.91 v34.52,33.91 35.28,33.91 35.66,33.53 37.19,33.53 37.41,33.76 38.3,33.76 U1.P$63 | v57.53,44.58 57.07,44.58 56.84,44.81 49.38,44.81 48.84,44.27 46.86,44.27 46.25,44.88 45.64,44.88 45.34,44.58 42.98,44.58 42.6,44.96 38.25,44.96 37.95,44.65 v36.96,44.65
  Bottom 0.152: 57.15,11.35 X7.3 58.37,12.65 58.37,17.45 58.9,17.98 58.9,20.8 58.52,21.18 58.52,27.13 58.75,27.36 58.75,28.27 58.52,28.5 58.52,32.31 57.53,33.3 57.53,36.88 58.37,37.72 58.37,41.45 57.53,42.29 v57.53,44.58 | v26.67,34.06 26.67,12.95 26.52,12.8 26.52,11.89 26.67,11.73 X11.77 | v36.96,44.65 36.58,44.27 36.58,40.39 34.82,38.63 34.82,34.21 v34.52,33.91
PK5  (via drill 0.3)
  Top 0.152: v55.24,14.33 53.03,14.33 52.43,14.94 50.52,14.94 49.84,15.62 47.4,15.62 46.71,14.94 43.05,14.94 41.53,13.41 40.46,13.41 40.23,13.18 37.57,13.18 37.34,13.41 35.89,13.41 35.59,13.11 v29.41,13.11 | v52.81,33.22 43.66,33.22 42.52,32.08 39.93,32.08 39.85,32.16 39.85,32.77 U1.P$62
  Bottom 0.152: X7.5 54.61,13.89 v55.24,14.33 55.24,15.32 55.32,15.39 55.32,22.78 56.69,24.16 56.69,25.3 55.17,26.75 55.17,27.96 53.42,29.72 53.42,31.62 52.96,32.08 52.96,32.61 52.81,32.77 v52.81,33.22 | v29.41,13.11 29.41,4.01 X11.75
PK6  (via drill 0.3)
  Top 0.152: X7.17 40.39,11.43 41.38,10.44 45.34,10.44 v45.72,10.06 | v40.69,32.69 40.16,32.69 40.16,32.99 39.58,33.58 U1.P$61
  Bottom 0.152: v45.72,10.06 45.72,9.53 45.49,9.3 45.49,8.31 43.66,6.48 43.66,4.65 44.42,3.89 44.45,4.14 | 44.5,4.19 44.45,4.14 | 44.45,4.14 X11.63 | v40.69,32.69 40.69,31.93 41.38,31.24 41.38,30.48 40.31,29.41 40.31,23.93 41.22,23.01 41.22,20.8 39.17,18.75 39.17,15.09 39.93,14.33 39.93,11.99 X7.17
PK7  (via drill 0.3)
  Top 0.152: v35.81,7.32 36.27,7.77 37.26,7.77 37.41,7.92 38.1,7.92 38.18,7.85 39.32,7.85 40.46,6.71 43.59,6.71 43.81,6.93 45.26,6.93 45.57,6.63 47.24,6.63 v47.55,6.33 | v41.6,32.77 41.07,33.3 40.46,33.3 U1.P$60 | v40.77,12.8 40.46,12.5 37.87,12.5 37.87,12.47 X7.19
  Bottom 0.152: X7.19 36.8,11.43 35.81,10.44 v35.81,7.32 | X11.59 49.53,5.56 48.77,6.33 v47.55,6.33 | v41.6,32.77 41.6,31.55 41.68,31.47 41.68,30.33 40.62,29.26 40.62,24.08 41.53,23.16 41.53,20.57 39.47,18.52 39.47,16.69 40.77,15.39 v40.77,12.8
PL0  (via drill 0.3)
  Top 0.152: X9.13 107.9,11.48 107.9,11.89 105.92,13.87 105.08,13.87 104.78,13.56 96.16,13.56 95.86,13.87 93.27,13.87 92.96,13.56 89.15,13.56 88.7,14.02 88.7,14.48 87.78,15.39 80.7,15.39 79.86,14.55 v69.88,14.55 65.84,14.55 65,13.72 54.79,13.72 54.71,13.79 53.11,13.79 52.27,14.63 50.37,14.63 49.68,15.32 47.55,15.32 46.86,14.63 43.43,14.63 43.2,14.4 43.2,13.34 42.67,12.8 v42.22,12.8 | v42.75,24.61 42.75,25.07 42.67,25.15 42.67,25.53 43.23,26.08 U1.P$81
  Bottom 0.152: v69.88,14.55 69.88,3.83 X11.43 | v42.75,24.61 42.75,20.19 42.67,20.12 42.67,17.07 41.45,15.85 41.45,14.86 41.83,14.48 41.83,13.18 v42.22,12.8
PL1  (via drill 0.3)
  Top 0.152: X9.15 104.27,12.57 95.17,12.57 94.49,13.26 93.73,13.26 93.42,12.95 79.17,12.95 78.87,13.26 78.18,13.26 77.19,12.27 67.97,12.27 67.67,12.57 v67.21,12.57 66.75,12.57 66.45,12.27 63.09,12.27 62.87,12.5 51.51,12.5 v50.67,13.34 | v49.91,28.8 48.01,28.8 47.85,28.65 44.88,28.65 44.12,27.89 44.12,26.39 U1.P$82
  Bottom 0.152: v67.21,12.57 67.21,9.53 66.9,9.22 66.9,7.77 67.28,7.39 67.28,3.83 X11.45 | v50.67,13.34 50.67,15.24 49.99,15.93 49.99,23.16 50.22,23.39 50.22,24.99 49.53,25.68 49.53,28.42 v49.91,28.8
PL2  (via drill 0.3)
  Top 0.152: X9.17 102.03,11.43 100.89,10.29 99.75,10.29 98.91,11.12 65.53,11.12 65.38,10.97 v64.77,10.97 | v44.96,27.81 44.42,27.28 44.42,26.12 U1.P$83 | v45.49,15.54 45.8,15.24 46.56,15.24 47.24,15.93 49.99,15.93 50.67,15.24 52.58,15.24 53.19,14.63 54.56,14.63 54.86,14.94 57.99,14.94 58.52,14.33 63.09,14.33 63.86,14.94 v64.77,14.94
  Bottom 0.152: X11.47 v64.77,10.97 v64.77,14.94 | v44.96,27.81 44.42,27.28 44.42,26.14 44.58,25.98 44.58,25.76 45.03,25.3 45.03,23.16 45.72,22.4 45.72,16.23 45.49,16 v45.49,15.54
PL3  (via drill 0.3)
  Top 0.152: X9.19 65.53,11.43 65.3,11.66 64.31,11.66 64.08,11.43 v62.48,11.43 62.41,11.35 | v46.33,15.93 46.63,16.23 50.14,16.23 50.83,15.54 52.73,15.54 53.34,14.94 54.33,14.94 54.63,15.24 58.22,15.24 58.75,14.63 59.66,14.63 59.97,14.94 v62.64,14.94 | U1.P$84 45.03,26.17 v45.03,26.67
  Bottom 0.152: X11.49 62.26,10.44 62.48,10.67 62.48,11.2 62.23,11.46 62.23,11.3 v62.48,11.43 | v45.03,26.67 45.03,25.83 45.34,25.53 45.34,23.39 46.02,22.63 46.02,16.69 46.33,16.38 v46.33,15.93 | v62.64,14.94 62.64,13.87 62.48,13.64 v62.48,11.43 | 62.64,11.58 v62.48,11.43
PL4  (via drill 0.3)
  Top 0.152: X9.9 109.98,14.48 104.62,14.48 104.32,14.17 96.7,14.17 96.39,14.48 v92.28,14.48 | v90.37,26.14 88.85,26.14 88.24,25.53 82.3,25.53 82.22,25.45 80.01,25.45 75.67,21.11 68.43,21.11 68.12,21.41 58.22,21.41 57.45,22.17 54.03,22.17 53.72,21.87 v53.03,21.87 | v51.44,28.19 47.62,28.19 47.4,27.96 44.96,25.53 U1.P$85 | X11.65 42.9,4.8 50.52,4.8 v50.83,4.5
  Bottom 0.152: v92.28,14.48 91.82,14.48 90.07,16.23 90.07,25.3 90.37,25.6 v90.37,26.14 90.37,26.29 | 53.03,21.79 52.05,22.78 52.05,25.68 51.36,26.36 v51.44,28.19 | v50.83,4.5 49.99,5.33 49.99,7.77 50.52,8.31 50.52,9.45 50.83,9.75 50.83,11.81 51.51,12.5 52.05,12.5 52.5,12.95 52.5,16.54 53.72,17.75 53.72,20.57 53.03,21.26 53.03,21.79 | 53.03,21.79 v53.03,21.87
PL5  (via drill 0.3)
  Top 0.152: X9.11 107.75,14.17 104.85,14.17 104.55,13.87 96.47,13.87 96.16,14.17 92.89,14.17 92.58,13.87 91.82,13.87 91.52,14.17 v89.53,14.17 | v88.47,20.34 79.17,20.34 78.49,21.03 77.04,21.03 75.89,19.89 68.2,19.89 67.59,19.28 53.57,19.28 v53.11,19.74 | v50.75,27.51 50.06,27.51 49.68,27.89 47.78,27.89 45.34,25.45 45.34,25.38 44.67,24.7 U1.P$86 43.92,23.93 v43.43,23.93 | v42.06,15.32 41.76,15.01 28.73,15.01 26.14,12.42 26.14,11.81 25.91,11.58 v24.69,11.58
  Bottom 0.152: v89.53,14.17 89.53,14.78 88.7,15.62 88.7,19.66 88.47,19.89 v88.47,20.34 | v53.11,19.74 52.12,19.74 51.36,20.5 51.36,22.25 51.59,22.48 51.59,25.6 50.75,26.44 v50.75,27.51 | v43.43,23.93 43.43,23.32 43.2,23.09 43.2,16.23 42.29,15.32 v42.06,15.32 | v24.69,11.58 24.69,8 24.23,7.54 24.23,3.91 X11.79
PM0  (via drill 0.3)
  Top 0.152: X7.7 52.12,11.43 53.11,10.44 63.93,10.44 64.08,10.29 65.3,10.29 65.46,10.44 69.57,10.44 70.26,9.75 72.24,9.75 72.39,9.6 v72.39,9.68 | v52.05,31.62 51.59,31.17 51.59,30.25 50.83,29.49 48.16,29.49 47.62,28.96 44.73,28.96 43.43,27.66 43.13,27.66 U1.P$78
  Bottom 0.152: v72.39,9.68 X11.41 | v52.05,31.62 51.74,31.32 51.74,29.72 53.34,28.12 53.34,26.06 52.35,25.07 52.35,23.39 53.72,22.02 53.72,21.03 54.03,20.73 54.03,17.53 52.81,16.31 52.81,12.8 52.07,12.06 X7.7
PM1  (via drill 0.3)
  Top 0.152: v74.98,8.84 74.68,8.53 72.77,8.53 72.47,8.84 70.56,8.84 69.27,10.13 65.68,10.13 65.53,9.98 63.93,9.98 63.78,10.13 50.9,10.13 49.61,11.43 X7.9 49.53,11.35 | v49.38,30.1 48.08,30.1 47.24,29.26 44.58,29.26 43.36,28.04 42.95,28.04 U1.P$77
  Bottom 0.152: v74.98,8.84 74.98,3.86 X11.39 | v49.38,30.1 48.92,29.64 48.92,25.22 49.61,24.54 49.61,23.7 49.38,23.47 49.38,16.23 49,15.85 49,14.17 49.3,13.87 49.45,13.87 49.91,13.41 49.91,12.8 49.53,12.42 X7.9
PM2  (via drill 0.3)
  Top 0.152: X7.11 47.14,11.23 47.14,10.62 48.23,9.53 48.69,9.53 49.07,9.91 50.6,9.91 51.05,9.45 51.05,8.38 51.59,7.85 52.5,7.85 52.96,8.31 53.26,8.31 54.03,7.54 62.33,7.54 62.87,8.15 66.45,8.15 66.67,7.92 69.72,7.92 70.41,7.24 76.66,7.24 76.96,7.54 v77.42,7.54 | v47.32,30.56 47.24,30.56 46.79,30.1 44.96,30.1 43.2,28.35 42.69,28.35 U1.P$76
  Bottom 0.152: X11.37 77.47,7.49 v77.42,7.54 | v47.32,30.56 47.02,30.25 47.02,26.29 48.01,25.3 48.01,22.78 48.77,22.02 48.77,16.54 46.33,14.1 46.33,12.12 46.99,11.46 X7.11
PM3  (via drill 0.3)
  Top 0.152: v82.6,6.63 84.35,6.63 84.66,6.33 92.43,6.33 93.5,7.39 98.45,7.39 99.21,6.63 105.54,6.63 105.84,6.93 107.9,6.93 108.2,7.24 111.33,7.24 111.94,7.85 118.57,7.85 119.61,8.89 X9.4 | v80.01,16.61 75.89,16.61 75.21,17.22 73.3,17.22 72.85,17.68 70.18,17.68 69.88,17.37 68.81,17.37 68.43,17.75 52.05,17.75 51.44,18.36 44.27,18.36 43.51,17.6 40.39,17.6 v40.08,17.3 | v43.43,29.49 42.67,28.73 42.5,28.73 U1.P$75
  Bottom 0.152: X11.33 82.6,3.86 v82.6,6.63 82.6,14.02 v80.01,16.61 | v40.08,17.3 40.92,18.14 40.92,19.51 41.83,20.42 41.83,23.39 40.92,24.31 40.92,26.98 v43.43,29.49
PM4  (via drill 0.3)
  Top 0.152: X8.18 101.85,51.05 93.5,51.05 93.04,50.6 90.53,50.6 86.56,46.63 78.33,46.63 76.28,48.69 72.69,48.69 72.01,48.01 68.5,48.01 66.98,46.48 57.99,46.48 57.38,45.87 56.01,45.87 55.78,46.1 46.86,46.1 46.56,46.41 41.99,46.41 v41.68,46.1 | 14.63,21.41 v14.78,21.41 14.78,20.95 13.64,19.81 v13.18,19.81 | v14.63,25.07 23.47,25.07 23.7,24.84 23.77,24.77 23.93,24.61 28.96,24.61 29.18,24.84 29.87,25.53 32.38,25.53 32.69,25.83 36.12,25.83 36.65,26.36 39.55,26.36 41.25,28.06 U1.P$74 42.82,29.61 42.82,29.72 43.51,30.4 v43.59,30.4
  Bottom 0.152: v41.68,46.1 41.68,45.11 42.6,44.2 42.6,42.98 42.29,42.67 42.29,40.62 44.2,38.71 44.2,37.87 43.13,36.8 43.13,35.66 43.59,35.2 43.59,33.98 42.9,33.3 42.9,31.09 v43.59,30.4 | X11.92 10.36,2.74 10.36,5.11 11.96,6.71 11.96,15.16 12.88,16.08 12.88,17.83 13.18,18.14 v13.18,19.81 | v14.78,21.41 14.78,23.01 14.63,23.16 v14.63,25.07
PM5  (via drill 0.3)
  Top 0.152: X8.20 93.88,52.05 93.73,52.2 90.37,52.2 85.72,47.55 79.1,47.55 76.81,49.84 67.67,49.84 65.84,48.01 54.86,48.01 54.79,47.93 41.22,47.93 v41.07,48.01 | v13.18,25.76 15.16,25.76 15.54,25.38 23.7,25.38 23.93,25.15 24.16,24.92 28.8,24.92 29.18,25.3 29.03,25.15 29.72,25.83 32.23,25.83 32.54,26.14 35.97,26.14 36.5,26.67 39.32,26.67 39.47,26.82 U1.P$73 42.6,29.95 v42.6,30.4
  Bottom 0.152: X11.90 12.5,2.34 12.5,4.95 13.34,5.79 13.34,17.6 13.95,18.21 13.95,19.96 12.95,20.95 12.95,22.1 13.18,22.33 v13.18,25.76 | v42.6,30.4 42.6,33.45 43.28,34.14 43.28,34.9 42.82,35.36 42.82,37.03 43.81,38.02 43.81,38.56 41.99,40.46 41.99,42.82 42.29,43.2 42.29,43.97 41.07,45.19 v41.07,48.01
PM6  (via drill 0.3)
  Top 0.152: v15.01,26.52 15.85,25.68 24,25.68 24.46,25.22 28.65,25.22 29.57,26.14 32.08,26.14 32.38,26.44 35.81,26.44 36.65,27.28 v38.71,27.28 39.36,27.28 U1.P$72
  Bottom 0.152: v38.71,27.28 37.34,27.28 36.42,26.36 36.42,14.17 37.03,13.56 37.03,12.8 37.87,11.96 37.87,9.93 X7.20 | X11.88 13.89,1.27 12.8,2.36 12.8,4.72 13.64,5.56 13.64,17.37 15.54,19.28 15.54,25.98 v15.01,26.52
PM7  (via drill 0.3)
  Top 0.152: v16.15,26.36 16.69,26.36 17.07,25.98 24.23,25.98 24.69,25.53 28.5,25.53 28.73,25.76 29.41,26.44 31.93,26.44 32.23,26.75 35.66,26.75 36.8,27.89 39.4,27.89 U1.P$71 | v57.15,5.64 55.93,5.64 55.7,5.41 42.22,5.41 41.91,5.11 40.01,5.11 39.62,5.49 39.62,5.94 39.17,6.4 35.59,6.4 34.06,4.88 18.44,4.88 17.91,4.34 17.91,2.67 X11.86
  Bottom 0.152: v16.15,26.36 16.15,19.36 14.86,18.06 14.86,4.8 15.47,4.19 15.47,2.31 X11.86 | X7.4 v57.15,5.64
PN0  (via drill 0.3)
  Top 0.152: D2.A 25.68,6.24 | X11.85 18.26,5.56 24.99,5.56 25.67,6.24 25.68,6.24 | v25.91,20.88 26.59,20.88 30.18,17.3 36.8,17.3 38.02,18.52 42.82,18.52 43.59,19.28 45.41,19.28 46.33,20.19 47.85,20.19 48.77,21.11 48.77,22.48 50.29,24 50.29,25.6 50.67,25.98 51.17,25.98 U1.P$107 | 25.68,6.24 v25.68,6.25
  Bottom 0.152: v25.91,20.88 25.91,20.27 26.36,19.81 26.36,13.56 26.06,13.26 26.06,6.63 v25.68,6.25
PN1  (via drill 0.3)
  Top 0.152: D1.A v22.94,6.24 18.35,6.24 17.07,4.95 16.08,4.95 14.94,3.81 X11.87 | v25.07,21.64 26.29,21.64 30.33,17.6 36.5,17.6 37.72,18.82 42.6,18.82 43.36,19.58 45.26,19.58 46.1,20.5 47.7,20.5 48.46,21.26 48.46,22.63 49.99,24.16 49.99,25.76 50.52,26.29 51.43,26.29 U1.P$108
  Bottom 0.152: v25.07,21.64 25.07,19.36 25.91,18.52 25.91,14.78 22.86,11.73 22.86,9.83 23.09,9.6 23.09,8.08 22.86,7.85 22.86,6.31 v22.94,6.24
PN2  (via drill 0.3)
  Top 0.152: X9.16 105.36,8.89 104.32,7.85 99.9,7.85 99.14,8.61 92.43,8.61 91.36,7.54 86.56,7.54 85.95,8.15 77.04,8.15 76.81,7.92 v71.78,7.92 | v71.17,22.4 70.1,23.47 65.15,23.47 64.16,22.48 60.2,22.48 59.28,23.39 54.56,23.39 53.65,24.31 53.65,24.64 U1.P$109 | v12.72,14.86 12.72,16.84 16.61,20.73 23.39,20.73 27.43,16.69 40.39,16.69 41,17.3 43.74,17.3 44.5,18.06 51.21,18.06 51.82,17.45 68.28,17.45 68.66,17.07 v72.31,17.07
  Bottom 0.152: v71.17,22.4 71.78,21.79 71.78,17.07 | 71.78,17.07 v71.78,7.92 | X11.89 11.43,4.72 13.03,6.33 13.03,13.79 12.72,14.1 v12.72,14.86 | v72.31,17.07 71.78,17.07
PN3  (via drill 0.3)
  Top 0.152: X9.18 101.91,8.89 100.89,9.91 99.67,9.91 98.98,9.22 91.52,9.22 90.68,10.06 75.36,10.06 74.68,9.45 74.45,9.22 v73.15,9.22 | v72.24,22.4 71.55,23.01 70.71,23.77 64.85,23.77 63.86,22.78 60.35,22.78 59.44,23.7 54.79,23.7 54.01,24.48 54.01,24.84 U1.P$110 | v8.91,10.74 12.88,10.74 13.95,11.81 22.94,11.81 27.51,16.38 40.62,16.38 41.22,16.99 43.97,16.99 44.73,17.75 50.98,17.75 51.59,17.14 68.05,17.14 68.89,16.31 v72.85,16.31
  Bottom 0.152: v73.15,9.22 73.15,15.47 72.85,15.77 v72.85,16.31 72.85,16.76 73.15,17.07 73.15,20.27 72.24,21.18 v72.24,22.4 | X11.91 8.89,10.72 v8.91,10.74
PN4  (via drill 0.3)
  Top 0.152: v48.08,49.76 47.78,50.06 41,50.06 40.46,50.6 38.25,50.6 38.02,50.83 v38.02,50.98 | v52.27,26.36 52.73,26.67 53.11,26.29 53.12,26.29 U1.P$111 | v23.55,30.86 24.23,30.86 24.54,31.17 27.81,31.17 28.65,30.33 29.87,30.33 30.86,31.32 35.28,31.32 35.66,30.94 v36.2,30.94
  Bottom 0.152: v48.08,49.76 48.62,49.76 49.45,48.92 49.99,48.92 49.99,40.77 50.98,39.78 50.98,39.01 50.37,38.41 50.37,37.72 50.22,37.57 50.22,35.36 51.13,34.44 51.13,29.41 52.12,28.42 52.12,27.05 52.27,26.9 v52.27,26.36 | X6.19 38.02,53.42 v38.02,50.98 39.7,49.3 39.7,44.58 40.31,43.97 40.31,41.15 39.62,40.46 39.62,37.26 40.31,36.58 40.31,35.66 38.1,33.45 38.1,32.84 v36.2,30.94 | X11.81 21.57,4.27 21.57,6.02 20.12,7.47 20.12,10.97 19.58,11.51 18.75,11.51 17.14,13.11 17.14,18.06 20.73,21.64 20.73,22.86 23.55,25.68 v23.55,30.86
PN5  (via drill 0.3)
  Top 0.152: v49.3,49.99 48.84,50.44 41.22,50.44 40.84,50.83 40.84,53.14 X6.17 38.02,53.26 v35.66,53.26 | 52.77,27.28 v52.73,27.36 52.73,27.25 U1.P$112 | v19.89,31.32 20.27,31.7 22.33,31.7 23.93,33.3 26.75,33.3 27.28,33.83 27.28,34.44 28.5,35.66 30.1,35.66 v32,33.83
  Bottom 0.152: v49.3,49.99 49.99,49.3 50.14,49.3 50.29,49.15 50.29,40.92 51.28,39.93 51.28,38.86 50.67,38.25 50.67,35.36 51.44,34.59 51.44,29.57 52.73,28.27 v52.73,27.36 | X11.83 19.05,8.53 18.75,8.84 18.75,10.97 16.76,12.95 16.76,18.44 19.89,21.57 v19.89,31.32 | v32,33.83 32.08,33.83 32.69,34.37 32.69,37.8 35.51,40.69 35.51,49.61 35.05,50.06 35.05,52.65 v35.66,53.26
PP0  (via drill 0.3)
  Top 0.152: U1.P$118 56.32,27.05 v56.77,27.05
  Bottom 0.152: X6.5 53.57,53.57 53.57,44.12 54.1,43.59 54.1,32.92 55.63,31.39 55.63,30.63 56.46,29.79 56.46,27.36 v56.77,27.05 56.84,26.98 57.14,26.68 57.61,26.21 57.61,23.7 56.24,22.33 56.24,19.81 56.84,19.2 56.84,12.72 56.08,11.96 56.08,3.28 57.15,2.21 X11.54
PP1  (via drill 0.3)
  Top 0.152: v54.86,29.79 54.86,28.96 55.02,28.8 55.13,28.8 U1.P$119
  Bottom 0.152: X6.7 53.19,53.49 53.26,43.89 53.8,43.36 53.8,32.69 55.32,31.17 55.32,30.48 54.86,30.02 v54.86,29.79 55.7,29.79 55.93,29.57 55.93,27 57.3,25.7 57.3,23.85 55.93,22.48 55.93,19.66 56.54,19.05 56.54,12.95 55.78,12.19 55.78,3.28 54.61,2.11 X11.56
PP2  (via drill 0.3)
  Top 0.152: v77.65,24 77.65,23.55 75.89,21.79 70.87,21.79 69.49,23.16 65.46,23.16 64.47,22.1 58.6,22.1 57.91,22.78 52.1,22.78 U1.P$103 | X11.71 34.29,4.57 35.81,6.1 39.01,6.1 39.32,5.79 39.32,5.33 39.85,4.8 42.29,4.8 42.6,5.11 56.41,5.11 56.54,4.98 57.81,4.98 57.94,5.11 67.97,5.11 68.5,5.64 78.87,5.64 v79.17,5.94 | v77.8,9.45 78.33,8.91 100.33,8.91 X9.20
  Bottom 0.152: v77.65,24 77.65,21.41 76.05,19.81 76.05,17.14 77.65,15.54 77.65,9.6 v77.8,9.45 79.17,8.08 v79.17,5.94
PP3  (via drill 0.3)
  Top 0.152: X7.16 40.89,9.91 v32.77,9.91 | v59.13,22.71 58.52,22.71 58.14,23.09 52.36,23.09 U1.P$104 | v59.21,15.24 58.9,15.54 54.41,15.54 54.1,15.24 53.49,15.24 52.88,15.85 51.05,15.85 50.37,16.54 45.57,16.54 44.27,15.24 42.9,15.24 42.06,14.4 32.99,14.4 v32.38,13.79
  Bottom 0.152: X11.73 31.75,8.89 v32.77,9.91 32.38,10.29 v32.38,13.79 | v59.13,22.71 59.13,21.18 59.21,21.11 v59.21,15.24
PP4  (via drill 0.3)
  Top 0.152: 50.72,25.3 v50.9,25.38 50.9,24.92 51.05,24.77 51.25,24.77 U1.P$105 | v27.2,12.34 35.89,12.34 v36.42,12.8
  Bottom 0.152: v50.9,25.38 50.14,26.14 50.14,27.74 50.83,28.42 50.83,34.21 49.91,35.13 49.91,37.72 50.06,37.87 50.06,38.63 50.67,39.24 50.67,39.55 49.68,40.54 49.68,48.46 49.61,48.54 49.07,48.54 48.46,49.15 47.55,49.15 46.33,50.37 44.42,50.37 43.43,51.36 43.43,53.09 X6.15 40.46,53.16 40.46,45.26 41.91,43.81 41.91,43.36 40.69,42.14 40.69,41.07 39.93,40.31 39.93,37.41 40.69,36.65 40.69,35.36 38.48,33.15 38.48,32.46 37.03,31.01 37.03,30.33 36.65,30.02 36.65,27.13 36.12,26.59 36.12,13.95 36.42,13.64 v36.42,12.8 | X11.78 26.67,2.29 27.66,3.28 27.66,5.03 27.2,5.49 v27.2,12.34
PP5  (via drill 0.3)
  Top 0.152: v25.45,12.34 28.57,15.47 41.3,15.47 41.83,16 44.58,16 45.41,16.84 50.52,16.84 51.21,16.15 53.49,16.15 v53.8,15.85 | v53.42,23.7 52.89,23.7 U1.P$106
  Bottom 0.152: X11.80 24.13,2.11 25.15,3.12 25.15,5.18 24.77,5.56 24.77,7.32 25.45,8 v25.45,12.34 | X7.6 54.61,9.25 53.49,10.36 53.49,12.34 53.8,12.65 v53.8,15.85 53.8,16.31 54.63,17.14 54.63,22.25 53.42,23.39 v53.42,23.7
PQ0  (via drill 0.3)
  Top 0.152: X6.13 45.87,53.19 47.7,53.19 48.23,52.65 48.23,51.51 48.69,51.05 57.15,51.05 57.45,50.75 v57.91,50.75 | v59.89,34.29 58.52,34.29 58.22,34.59 57.99,34.59 U1.P$5
  Bottom 0.152: v57.91,50.75 60.2,48.46 60.2,43.43 59.59,42.82 59.59,35.43 59.89,35.13 v59.89,34.29 59.89,32.54 61.27,31.17 61.27,27.2 63.7,24.77 63.7,22.63 61.57,20.42 61.57,5.64 59.74,3.81 X11.51
PQ1  (via drill 0.3)
  Top 0.152: v58.67,34.98 57.8,34.98 U1.P$6 | 39.4,8.87 X7.18 40.31,7.95 40.31,7.47 40.77,7.01 43.43,7.01 43.66,7.24 45.41,7.24 45.72,6.93 48.23,6.93 49.07,6.1 53.8,6.1 54.33,6.63 58.6,6.63 v58.98,6.25
  Bottom 0.152: v58.67,34.98 58.67,32.99 58.83,32.84 58.83,31.47 58.98,31.32 58.98,30.25 59.05,30.18 59.05,23.62 59.97,22.71 59.97,17.53 60.58,16.92 60.58,12.12 60.73,11.96 60.73,8 v58.98,6.25 57.91,5.18 57.91,4.57 X11.53
PQ2  (via drill 0.3)
  Top 0.152: X7.12 46.99,8.87 | v53.11,7.62 52.73,7.62 52.65,7.54 51.36,7.54 50.98,7.92 50.14,7.92 50.06,7.85 49.15,7.85 48.77,8.23 47.65,8.23 X7.12 | v51.74,35.2 52.73,34.21 54.03,34.21 54.79,34.98 54.97,34.98 U1.P$11 | 47.02,8.91 X7.12 | R19.1 47.13,13.38 47.17,13.34 47.17,12.72 47.62,12.27 v48.23,12.27
  Bottom 0.152: v51.74,35.2 51.74,34.59 52.12,34.21 52.12,32.99 52.65,32.46 52.65,31.32 52.05,30.71 52.05,29.87 53.65,28.27 53.65,25.83 52.65,24.84 52.65,23.62 54.03,22.25 54.03,21.18 54.33,20.88 54.33,17.37 53.11,16.15 v53.11,7.62 54.71,7.62 55.4,6.93 55.4,4.57 X11.55 | v48.23,12.27 48.23,10.13 X7.12
PQ3  (via drill 0.3)
  Top 0.152: v50.6,7.32 49.23,7.32 48.69,7.85 46.48,7.85 45.49,8.84 44.96,8.84 X7.14 | v44.81,33.83 45.34,33.83 46.02,34.52 48.23,34.52 48.54,34.21 49.15,34.21 49.23,34.29 v49.68,34.29 | v49.84,39.32 50.29,39.32 51.07,40.09 U1.P$27 | v45.41,12.57 44.88,13.11 44.88,13.41 R20.1
  Bottom 0.152: v45.41,12.57 45.41,12.04 45.49,11.96 45.49,10.97 44.42,9.91 44.42,8.99 44.5,8.91 X7.14 | v49.68,34.29 49.68,34.82 49.53,34.98 49.53,37.8 49.76,38.02 49.76,39.09 49.84,39.17 v49.84,39.32 | v44.81,33.83 43.81,32.84 43.81,32 44.81,31.01 44.81,28.5 44.12,27.81 44.12,25.91 44.2,25.83 44.2,25.6 44.73,25.07 44.73,22.94 45.34,22.25 45.34,16.31 44.81,15.77 44.81,15.32 45.41,14.71 v45.41,12.57 | 45.41,12.5 v45.41,12.57 | X11.57 52.07,5.84 v50.6,7.32
PQ4  (via drill 0.3)
  Top 0.152: U4.5 81.31,41.45 81.46,41.3 82.6,41.3 82.83,41.53 82.83,41.6 v82.91,41.68 | v79.48,17.98 78.94,17.98 78.18,17.22 76.2,17.22 75.89,17.53 73.53,17.53 73.08,17.98 v69.49,17.98 68.73,17.98 68.66,18.06 52.27,18.06 51.66,18.67 49,18.67 48.08,19.58 47.55,19.58 46.94,18.97 43.81,18.97 43.05,18.21 38.25,18.21 37.03,16.99 27.74,16.99 26.52,18.21 23.62,21.03 16.38,21.03 11.73,16.38 11.73,13.87 11.73,12.34 10.9,11.51 10.59,11.51 9.37,11.51 8.46,11.51 8,10.9 v6.25,10.9 | v69.11,21.79 58.37,21.79 57.68,22.48 51.82,22.48 51.07,23.23 U1.P$102
  Bottom 0.152: v82.91,41.68 82.83,41.68 81.08,39.93 81.08,33.6 | 81.08,33.6 81.15,33.53 | 81.08,33.6 81.08,19.58 v79.48,17.98 | X11.93 6.33,4.27 6.33,4.8 6.2,4.93 6.2,10.16 6.25,10.21 v6.25,10.9 | v69.11,21.79 69.49,21.41 v69.49,17.98
RBIAS
  Top 0.152: R25.1 37.72,35.74 38.71,34.75 39.57,34.75 U1.P$59
TARGET_ID  (via drill 0.3)
  Top 0.152: U2.2 6.55,24.13 v6.53,24.11 | R18.2 16.99,22.78 16.76,22.55 13.79,22.55 13.03,21.79 13.03,20.65 TP7.TP 8.46,22.02 v6.93,22.02 5.78,23.18 U7.P4
  Bottom 0.152: v6.53,24.11 6.63,24.08 6.63,23.01 6.93,22.71 v6.93,22.02
TARGET_RXD
  Top 0.152: X1.12 R7.1 82.37,26.52 82.34,26.48 82.34,26.25 81.84,25.76 76.56,25.76 JP4.1
TARGET_TCK/SWCLK
  Top 0.152: X1.10 R8.1 82.37,23.62 82.14,23.39 80.09,23.39 79.78,23.7 78.72,23.7 75.82,20.8 68.12,20.8 67.82,21.11 57.91,21.11 57.15,21.87 54.86,21.87 54.79,21.79 54.79,21.2 R1.2 54.69,21.11 51.44,21.11 51.13,21.41 51.13,22.06 U1.P$100
TARGET_TDI
  Top 0.152: X1.6 R11.1 82.37,18.97 82.37,18.52 82.34,18.48 82.14,18.29 80.7,18.29 78.41,20.57 77.04,20.57 75.74,19.28 72.85,19.28 72.62,19.51 68.58,19.51 68.05,18.97 52.96,18.97 52.35,19.58 50.98,19.58 50.52,20.04 50.52,21.54 U1.P$98
TARGET_TDO/SWO  (via drill 0.3)
  Top 0.152: X1.4 R15.1 82.45,16.38 82.45,16.08 82.14,15.77 v74.83,15.77 | v74.83,18.67 72.92,18.67 72.47,19.13 68.81,19.13 68.35,18.67 52.73,18.67 52.12,19.28 49.45,19.28 49.07,19.66 49.07,21.26 U1.P$97
  Bottom 0.152: v74.83,18.67 v74.83,15.77
TARGET_TMS/SWDIO
  Top 0.152: X1.8 R10.1 82.37,21.57 82.37,21.03 82.14,20.8 79.25,20.8 78.64,21.41 76.89,21.41 75.97,20.5 67.74,20.5 67.44,20.8 57.91,20.8 56.69,19.58 54.86,19.58 54.77,19.68 R2.2 54.67,20.34 51.21,20.34 50.83,20.73 50.83,21.79 U1.P$99
TARGET_TXD  (via drill 0.3)
  Top 0.152: R6.1 X1.14 | JP5.1 85.01,31.75 v85.11,31.85
  Bottom 0.152: v85.11,31.85 85.11,29.23 X1.14
TARGET_VBUS  (via drill 0.3)
  Top 0.152: 9.04,24.64 v9.14,24.54 | X11.60 48.49,1.27 47.32,2.44 v43.28,2.44 | v13.72,21.03 14.17,21.49 14.17,21.72 14.55,22.1 21.34,22.1 21.49,22.25 26.21,22.25 30.56,17.91 36.27,17.91 37.49,19.13 42.37,19.13 43.59,20.34 v44.42,20.34 44.88,20.8 46.46,20.8 U1.P$96
  Top 0.254: 9.04,24.64 U2.6
  Top 0.356: 81.74,42.09 U4.6
  Top 0.381: JP1.3 73.69,43.2 75.36,43.2 76.2,44.04 81.61,44.04 v81.84,43.89 | v81.84,41.99 81.74,42.09 | v36.96,34.67 32.69,34.67 30.94,36.42 27.81,36.42 25.22,33.83 23.62,33.83 21.95,32.16 13.34,32.16 11.43,30.25 TP4.TP 7.09,26.67 5.52,25.11 5.5,25.12 U7.P1 | v70.87,48.92 68.2,48.92 66.52,47.24 55.78,47.24 55.02,46.56 47.09,46.56 46.79,46.86 39.55,46.86 39.09,46.41 v38.56,46.41
  Bottom 0.152: v9.14,24.54 9.14,25.65 TP4.TP 11.46,27.96 13.03,27.96 13.95,27.05 13.95,24.69 13.72,24.46 v13.72,21.03 | v43.28,2.44 43.28,6.33 42.14,7.47 42.14,7.54 43.05,8.46 43.05,11.58 43.28,11.81 43.28,15.24 44.42,16.38 v44.42,20.34
  Bottom 0.381: v81.84,43.89 81.53,43.59 81.53,42.29 v81.84,41.99 | v36.96,34.67 37.26,34.98 37.26,38.94 39.78,41.45 39.78,42.22 38.56,43.43 v38.56,46.41 | v70.87,48.92 70.87,43.43 JP1.3
TARGET_VDDC
  Top 0.152: TP12.TP 62.26,24.16 | 54.75,26.93 U1.P$115
  Top 0.229: 54.75,26.93 55.4,26.29
  Top 0.254: C4.1 41.53,23.55 41.91,23.16 43.74,23.16 43.74,23.18 U1.P$87 47.99,27.43 49.3,27.43 49.99,26.75 51.05,26.75 52.43,28.12 53.11,28.12 53.49,27.74 53.94,27.74 U1.P$115 | 55.4,26.29 56.83,26.29 C15.1 | C14.1 57.99,25.15 57.8,25.34 57.8,25.48 C15.1 | TP12.TP 62.23,26.01 61.65,26.59 58.52,26.59 57.84,25.91 C15.1
USBD_N
  Top 0.203: 45.96,22.01 U1.P$93
  Top 0.229: 45.95,22.01 45.96,22.01
  Top 0.275: 45.95,22.01 42.58,22.01 40.83,20.25 35.06,20.25 34.3,21.02 30.72,21.02 27.67,24.06 13.34,24.06 13.34,24.13 TP5.TP 10.16,25.4 7.77,25.4 7.42,25.04 U2.1 6.99,24.64 6.83,24.79 6.22,24.79 5.89,24.46 5.88,24.48 U7.P2
USBD_P
  Top 0.203: 45.95,21.58 46.1,21.58 U1.P$94
  Top 0.275: 45.95,21.58 42.76,21.58 41.01,19.83 34.89,19.83 34.12,20.59 30.54,20.59 27.5,23.64 13.34,23.64 13.34,23.5 TP6.TP 10.16,22.86 7.77,22.86 7.39,23.24 U2.3 6.99,23.62 6.86,23.5 6.86,23.47 6.78,23.39 6.33,23.39 6.25,23.47 6.2,23.5 5.87,23.82 U7.P3
VBAT  (via drill 0.3)
  Top 0.152: R38.1 33.15,28.79 33.22,28.8 | 33.22,28.8 32.69,28.8 32.38,29.11 32,29.11 31.93,29.18 31.85,29.17 R42.1 | 33.22,28.8 33.3,28.8 33.3,29.34 v33.76,29.79 | R39.1 31.93,22.48 31.93,23.24 31.76,23.41 31.76,23.5 TP11.TP
  Bottom 0.152: v33.76,29.79 33.76,26.14 TP11.TP
VBUS
  Top 0.152: R36.2 79.9,39.9 79.86,39.85 R35.1 | R35.1 78.88,39.87 78.26,39.24 77.04,39.24 76.73,39.55 75.11,39.55 JP1.6 | R35.1 79.65,39.84 R35.1
  Top 0.356: U4.2 77.04,42.75 76.2,41.91
  Top 0.381: 76.2,41.91 JP1.4 | 74.95,39.4 JP1.6
  Bottom 0.381: JP1.2 JP1.4 JP1.6
VCP_RXD  (via drill 0.3)
  Top 0.152: R6.2 82.31,30.25 86.56,30.25 87.61,29.21 X1.13 87.66,29.18 90.22,29.18 91.59,27.81 96.09,27.81 97.46,29.18 v99.67,29.18 | U20.P$17 105.45,24.53 105.08,24.16 103.78,24.16 100.66,27.28 v99.67,27.28
  Bottom 0.152: v99.67,29.18 v99.67,27.28
VCP_TXD
  Top 0.152: R7.2 82.26,27.66 86.79,27.66 87.63,26.82 X1.11 87.71,26.75 99.21,26.75 99.36,26.59 100.81,26.59 103.56,23.85 105.31,23.85 105.95,24.5 U20.P$18
VERSION_0  (via drill 0.3)
  Top 0.152: v104.09,43.97 104.09,44.65 104.1,44.66 104.01,44.74 R12.1 | v105.39,39.47 105.99,38.86 105.99,38.79 106.95,37.83 U20.P$61
  Bottom 0.152: v105.39,39.47 104.09,40.77 v104.09,43.97
VERSION_1  (via drill 0.3)
  Top 0.152: U20.P$47 114.85,34.37 113.46,34.37 112.32,33.22 v108.89,33.22 | v105.16,43.97 105.18,43.84 R13.1
  Bottom 0.152: v105.16,43.97 105.16,43.05 105.99,42.22 105.99,36.12 v108.89,33.22
VERSION_2  (via drill 0.3)
  Top 0.152: U20.P$48 114.88,34.9 113.16,34.9 111.94,33.68 109.5,33.68 v108.97,34.21 | v106.38,43.97 106.35,43.84 R14.1
  Bottom 0.152: v108.97,34.21 106.38,36.8 v106.38,43.97
VREF+  (via drill 0.3)
  Top 0.152: v84.05,32.69 81.53,32.69 81.38,32.84 72.01,32.84 70.1,34.75 64.29,34.75 63.83,34.29 TP13.TP 62.19,34.33 62.26,34.29 61.78,34.76 61.55,34.76 60.88,35.43 60.88,35.89 60.81,35.97 R41.1 60.1,36.02 59.66,35.59 56.71,35.59 U1.P$9
  Bottom 0.152: X11.34 84.05,2.77 v84.05,32.69
VREG_EN  (via drill 0.3)
  Top 0.152: v94.64,34.9 94.03,34.9 93.73,34.59 93.73,33.83 93.8,33.76 R17.2 92.96,33.6 92.28,34.29 TP3.TP
  Top 0.305: U5.4 96.99,39.84 v97.46,40.31
  Bottom 0.152: v97.46,40.31 97.46,39.24 96.47,38.25 94.94,38.25 94.64,37.95 v94.64,34.9

## Text on the board
Bottom: EK-TM4C129EXL / REV A
tPlace: DEBUG | TXD | RXD | Target USB | TCK | TMS | TDI | BoosterPack 2 | TDO | BoosterPack 1 | !RESET | TM4C Series Crypto / Connected LaunchPad | 85 | 71 | 57 | 43 | 29 | 15 | 1
bPlace: TXD | RXD | TCK | TMS | TDI | TDO | !RESET
tNames: POWER | http://www.ti.com/launchpad | POWER SELECT | U22 | BoosterPack | +3v3 | OTG | ICDI | U14 | CAN | UART | MCU 3V3 | Y2 | CAN | Y1 | UART | EK-TM4C129EXL Rev A
bNames: +3v3 / PD2 / PP0 / PP1 / See JP4 / See JP5 / PQ0 / PP4 / PN5 / PN4 | +5V / GND / PB4 / PB5 / PK0 / PK1 / PK2 / PK3 / PA4 / PA5 | TP1 | TP8 | +3V3 / PE4 / PC4 / PC5 / PC6 / PE5 / PD3 / PC7 / PB2 / PB3 | TP10 | TP13 | TP3 | +5V / GND / PE0 / PE1 / PE2 / PE3 / PD7 / PA6 / PM4 / PM5 | TP9 | BP2_A2.6 / PA1 | PD5 / ICDI_TX | For Evaluation Only; | TP4 | Not FCC approved for resale | TP5 | PG1 / PK4 / PK5 / PM0 / PM1 / PM2 / PH0 / PH1 / PK6 / PK7 | TP12 | BP2_A2.5 / PA0 | PD4 / ICDI RX | TP2 | TP6 | TP11 | PF1 / PF2 / PF3 / PG0 / PL4 / PL5 / PL0 / PL1 / PL2 / PL3 | TP7 | GND / PM7 / PP5 / PA7 / !RESET / PQ2/PA3 / PQ3/PA2 / PP3 / PQ1 / PM6 | GND / PM3 / PH2 / PH3 / !RST / PD1 / PD0 / PN2 / PN3 / PP2 | 5V / 3V3 | !WAK / GND | PQ4 / !RST | PN3 / PM4 | PN2 / PM5 | PN1 / PM6 | PN0 / PM7 | PN5 / PJ1 | PN4 / PJ0 | PL5 / PP5 | PK4 / PP4 | PK5 / PA1 | PP3 / PA0 | PP2 / PF3 | PB3 / PF2 | PB2 / PF1 | PL4 / PF0 | PK6 / PF4 | GND / GND | PK7 / PB1 | PQ3 / PB0 | PQ2 / PP1 | PQ1 / PP0 | PQ0 / PD2 | PL3 / PD0 | PL2 / PD1 | PL1 / PD3 | PL0 / PD6 | PM0 / PD7 | PM1 / PD4 | PM2 / PD5 | GND / GND | PM3 / REF | PG0 / PK3 | PG1 / PK2 | PA7 / PK1 | PA6 / PK0 | PC4 / PE5 | PC5 / PE4 | PC6 / PE3 | PC7 / PE2 | PH3 / PE1 | PH2 / PE0 | PH1 / PA5 | PH0 / PA4 | PB5 / PA3 | PB4 / PA2 | GND / GND | 3V3 / 5V
Document: Layer Stackup / Top silkscreen / Top Solder Mask / Component Side / Layer 2 / Layer 3 / Solder Side / Bottom Solder Mask / Bottom Silkscreen | File Names / EK-TM4C129EXL.sst / EK-TM4C129EXL.smt / EK-TM4C129EXL.l1 / EK-TM4C129EXL.l2 / EK-TM4C129EXL.l3 / EK-TM4C129EXL.l4 / EK-TM4C129EXL.smb / EK-TM4C129EXL.ssb | NOTES: UNLESS OTHERWISE SPECIFIED / 1) Manufacture in accordance with IPC-6012, Type 3, Class 2. / 2) End Product Features shall not vary more than 20% from artwork originals / 3) Material shall be ROHS compliant, copper clad FR-406, NEMA Grade (Tg 170degC) / Per IPC-4101, Color Natural, or equivalent / 4) Construction shall be symetrical multilayer per layer stackup detail / 5) Copper weight on inner layers shall be 1 oz per square foot / 6) Equivalent copper weight on outler layers shall be 1.0 oz per square foot before plating / 7) All plated through holes shall have a minimum of 0.0007 inches of copper / 8) Drill hole tolerance after plating shall be +/- 0.003 inches / 9) Minimum annular ring shall be 0.001 inches / 10) Minmum annular rint at emergent conductors shall be 0.003 inches / 11) PCB Thickness shall be 0.062 inches +/- 0.007 inches / 12) Warp / Twist shall not exceed 0.010 inches per inch / 13) Finish shall be LPI, Gloss RED SMOBC, Both sides balance of exposed copper shall be HASL / 14) Silkscreen with nonconductive white epoxy ink / 15) Board stack-up should be targetted such that a differential impedance of 90 ohms +/- 10% can / be achieved on the top layer with 10.8 mil traces and 6 mil spacing. Additionally 100 ohm +/- 10% / with 8.7 mil traces and 6 mil spacing. Boards do not need to be impedance controlled.